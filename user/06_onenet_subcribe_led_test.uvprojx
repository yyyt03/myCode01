# Keil uVision project 06_onenet_subcribe_led_test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 04_esp8666_linkonenet_test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103_MD,USE_STDPERIPH_DRIVER
  c include: ..\core;..\fwlib\inc;..\hardware\inc;..\user;..\NET\device\inc;..\NET\MQTT;..\NET\onenet\inc;..\NET\cJSON;..\hardware\BH1750;..\hardware\sys;..\hardware\timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c main.h
  group CORE
    ../core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group FWLIB
    ../fwlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../hardware/src/: beep.c usart.c oled.c DHT11.c key.c delay.c led.c
    ../hardware/BH1750/: bh1750.c myiic.c
    ../hardware/sys/: sys.c
    ../hardware/timer/: timer.c
  group NET
    ../NET/device/src/: esp8266.c
    ../NET/onenet/src/: base64.c hmac_sha1.c onenet.c
    ../NET/MQTT/: MqttKit.c
    ../NET/cJSON/: cJSON.c
